# Keil uVision project example.uvprojx, settings and files
target example (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L011_DFP.1.0.1
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x01800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LCD_DEMO,EN_SW_DEBUG
  c include: ..\chip\cw32l011\StdDriver\inc;..\chip\cw32l011\CMSIS\dev\inc;..\SEGGER\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group app
    ../app/: app_lowpower.c app_module.c app_sleep.c main.c
    ../examples/telephone/: telephone.c
  group mcu-drv
    ../config/: config.c
    ../dev/src/: log.c matrix.c sys_tick.c
    ../hal/src/: hal-storage.c hal_key.c
    ../lib/RTT/: SEGGER_RTT_printf.c SEGGER_RTT_Conf.h SEGGER_RTT.h SEGGER_RTT.c
    ../lib/: timer_affair.c storage.c rb.c misc.c key.c
    ../drv/src/: drv_uart.c drv_timer.c drv_rcc.c drv_gpio.c
    ../chip/cw32l011/CMSIS/dev/src/: startup_cw32l011.s system_cw32l011.c
    ../chip/cw32l011/StdDriver/src/: cw32l011_adc.c cw32l011_atim.c cw32l011_btim.c cw32l011_crc.c cw32l011_debug.c cw32l011_digitalsign.c cw32l011_flash.c cw32l011_gpio.c cw32l011_gtim.c cw32l011_i2c.c cw32l011_iwdt.c cw32l011_lptim.c cw32l011_lvd.c cw32l011_pwr.c cw32l011_ram.c cw32l011_rtc.c cw32l011_spi.c cw32l011_sysctrl.c cw32l011_systick.c cw32l011_uart.c cw32l011_vc.c i2c_eeprom.c
  group ex1-drv
    ../hal/src/: hal-at.c
    ../dev/src/: at.c module.c
software components: CMSIS:CORE 5.3.0
